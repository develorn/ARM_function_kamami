# Keil uVision project cw28.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Cw28 +hex
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .;..\STM32F10x_StdPeriph_Lib_V3.3.0\Libraries\CMSIS\CM3\CoreSupport;..\STM32F10x_StdPeriph_Lib_V3.3.0\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32F10x_StdPeriph_Lib_V3.3.0\Libraries\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group UserCode
    ./: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../Moduly/LCD1602/: lcd_hd44780_lib.h lcd_hd44780_lib.c
    ../Moduly/BAR/: bar_spi_lib.h bar_spi_lib.c
  group StdPeriphDrv
    ../STM32F10x_StdPeriph_Lib_V3.3.0/Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_flash.c misc.c stm32f10x_gpio.c stm32f10x_spi.c
  group CMSIS
    ../STM32F10x_StdPeriph_Lib_V3.3.0/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c core_cm3.h
    ../STM32F10x_StdPeriph_Lib_V3.3.0/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c stm32f10x.h system_stm32f10x.h
  group RVMDK
    ./: mod_startup_stm32f10x_md.s
